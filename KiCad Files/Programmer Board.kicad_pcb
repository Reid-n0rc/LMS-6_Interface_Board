# Repository Reid-n0rc/LMS-6_Interface_Board

File README.md:

# LMS-6_Interface_Board
Interface to the LMS-6 radiosonde carde edge connector.

This project provides an easy way to connect to the UARTs, in circuit programming of the ST7, and provide power to the LMS6 Radiosonde using a card edge connector.

# Fabrication Notes
## Fabrication Files
File for fabrication are in (./Fabrication) directory.  This contains the gerber files and BOM
# Build Notes
## Minimum build
Depending on how you intend on using this board, many of the parts can be omitted. The minimal build provides a connection for the ST7 programmer and card edge interface. The LMS6 will be powered by the CR123 batteries installed on the LMS6.  This configuration requires J5, J6, J7, and one shunt connector (jumper).

J6 has pins 1 and 2 jumpered together to connect the battery power.  The shunt connector will allow the LMS6 to be turned on and off.

## 9V Regulated Supply

## 4.5V to 18V Supply

## UART1

## UART2
JP3 needs cut and the alternate postion soldered to receive data from the debugging port. Debugging seial is 8N1 at 500kbits/sec.

## KiCad design KiCad Files/Programmer Board.kicad_pcb

Parts:
J1, J12: 105-1103-001; Test_Jack_Horiz; MPN 105-1103-001; Digi-Key_PN J577-ND
J2, J10: Conn_01x03; PinHeader_1x03_P2.54mm_Vertical; MPN 61300311121
J3, J11: 105-1102-001; Test_Jack_Horiz; MPN 105-1102-001; Digi-Key_PN J576-ND
J7: 302-S101; PinHeader_2x5_P2.54mm_Drill1.2mm; MPN 302-S101
J9: Conn_02x18_Odd_Even; PinHeader_2x18_P2.54mm_Vertical; MPN PREC018DAAN-RC

Connections:
/+PS: J2.1, J3.1
/Card Edge Conn/9V_PS: J10.2; also elsewhere on the board
/Card Edge Conn/HEADER1.1: J9.5; also elsewhere on the board
/Card Edge Conn/HEADER1.2: J9.13; also elsewhere on the board
/Card Edge Conn/HEADER1.3: J9.15; also elsewhere on the board
/Card Edge Conn/HEADER1.4: J9.19; also elsewhere on the board
/Card Edge Conn/HEADER1.5: J9.17; also elsewhere on the board
/Card Edge Conn/HEADER1.6: J9.21; also elsewhere on the board
/Card Edge Conn/HEADER1.7: J9.25; also elsewhere on the board
/Card Edge Conn/HEADER1.9: J9.31; also elsewhere on the board
/Card Edge Conn/HEADER1.10: J9.35; also elsewhere on the board
/Card Edge Conn/J5.2: J9.3; also elsewhere on the board
/Card Edge Conn/J5.3: J9.27; also elsewhere on the board
/Card Edge Conn/ST7-ICCCLK: J7.4; also elsewhere on the board
/Card Edge Conn/ST7-ICCDATA: J7.2; also elsewhere on the board
/Card Edge Conn/ST7-ICCSEL: J7.8; also elsewhere on the board
/Card Edge Conn/ST7-RESET: J7.6; also elsewhere on the board
/Card Edge Conn/SW1.1: J9.9; also elsewhere on the board
/Card Edge Conn/SW1.2: J9.11; also elsewhere on the board
/Card Edge Conn/SW1.3: J9.29; also elsewhere on the board
/Card Edge Conn/SW1.4: J9.7; also elsewhere on the board
/Card Edge Conn/U3.18: J9.33; also elsewhere on the board
/Card Edge Conn/U21.20-DCLK: J9.1; also elsewhere on the board
/Card Edge Conn/U22.3: J9.23; also elsewhere on the board
/DC-DC Converter/+V_out: J10.3; also elsewhere on the board
/USB to UART/+5_USB: J2.3; also elsewhere on the board
/eFuse/eFuse_In: J2.2; also elsewhere on the board
GND: J1.1, J7.1, J7.3, J7.5, J7.10, J9.2, J9.4, J9.6, J9.8, J9.10, J9.12, J9.14, J9.16, J9.18, J9.20, J9.22, J9.24, J9.26, J9.28, J9.30, J9.32, J9.34, J9.36, J12.1; also elsewhere on the board
unnamed: J10.1, J11.1
VDD: J7.7; also elsewhere on the board

Notes on the sheet:
External power source select. Jumper 1-2 for banana jacks. Jumper 2-3 for USB power.
Jumper 1-2: Direct Power LMS6 Jumper 2-3: Power LMS6 through supplies

Parts:
C3, C5, C6: 0.1uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder; MPN CL21B104KBCNNNC
C4: 33nF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder; MPN 885012207095
C7: 10uF; CP_EIA-3216-10_Kemet-I_Pad1.58x1.35mm_HandSolder; MPN T491A106K010AT
D2: LG R971-KN-1; 0805; MPN LG R971-KN-1; Digi-Key_PN 475-1410-1-ND
FB1, FB2: MPZ2012S601AT000; 0805; MPN MPZ2012S601AT000; Digi-Key_PN 445-2206-1-ND
J4: UJ2-MIBH-4-SMT-TR; USB_Micro_B_Male_UJ2-MIBH-4-SMT-TR; MPN UJ2-MIBH-4-SMT-TR; Digi-Key_PN 102-4006-1-ND
JP4, JP5: JUMPER-SMT_3_1-NC; SMT-JUMPER_3_1-NC_TRACE_NO-SILK
R1, R2: 27; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder; MPN CRG0805F27R
R3: 1.5K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder; MPN CRGCQ0805F1K5
R4: 10k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder; MPN RC1005F103CS
R5: 470; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder; MPN RC0805JR-07470RL
R11: 280; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder; MPN RC0805FR-07280RL
R13: 1M; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder; MPN RC0805FR-071ML
U1: FT2232D-REEL; LQFP-48_7x7mm_Narrow_Pad; MPN FT2232D-REEL; Digi-Key_PN 768-1010-1-ND
Y1: CSTNR6M00GH5C000R0; CSTNR_Resonator; MPN CSTNR6M00GH5C000R0

Connections:
/Card Edge Conn/GPS.RXD: U1.24 (ADBUS0); also elsewhere on the board
/Card Edge Conn/GPS.TXD: U1.23 (ADBUS1); also elsewhere on the board
/Card Edge Conn/U3.19: JP4.2, JP4.3, JP5.1, U1.40 (BDBUS0); also elsewhere on the board
/USB to UART/3V3OUT: C4.1, U1.6 (3V3OUT)
/USB to UART/+5_USB: C5.1, C6.1, C7.1, D2.1, FB2.2, R4.2, R5.2, U1.3 (VCC), U1.4 (RESET), U1.14 (VCCIOA), U1.31 (VCCIOB), U1.42 (VCC); also elsewhere on the board
/USB to UART/IN_USBD_N: J4.3, R2.2
/USB to UART/IN_USBD_P: J4.2, R1.2
/USB to UART/RSTOUT: R3.1, U1.5 (RSTOUT)
/USB to UART/UART2.RXD: JP4.1, JP5.2, JP5.3, U1.39 (BDBUS1)
/USB to UART/USBD_N: R2.1, U1.8 (USBDM)
/USB to UART/USBD_P: R1.1, R3.2, U1.7 (USBDP)
/USB to UART/XOUT: R13.1, U1.44 (XTOUT), Y1.3
/USB to UART/XTIN: R13.2, U1.43 (XTIN), Y1.1
GND: C3.2, C4.2, C5.2, C6.2, C7.2, FB1.2, J4.5, R11.2, U1.9 (GND), U1.18 (GND), U1.25 (GND), U1.34 (GND), U1.45 (AGND), U1.47 (TEST), Y1.2; also elsewhere on the board
unnamed: C3.1, R5.1, U1.46 (AVCC)
unnamed: D2.2, R11.1
unnamed: FB1.1, J4.SH
unnamed: FB2.1, J4.1
unnamed: R4.1, U1.2 (EEDATA)

Parts:
C8: 10uF; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder; MPN CL31A106KAHNNNE
C9: 4.7uF; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder; MPN CL31B475KAHNNNE
L1: TCK-154; TCK154; Mouser Part Number 495-TCK-154
U2: TEC2-1219WI; Converter_DCDC_TRACO_TMR-xxxx_THT

Connections:
/DC-DC Converter/+V_in: C8.1, L1.1; also elsewhere on the board
/DC-DC Converter/+V_out: U2.6 (+VOUT); also elsewhere on the board
GND: C8.2, C9.2, U2.1 (-VIN), U2.7 (-VOUT); also elsewhere on the board
unnamed: C9.1, L1.2, U2.2 (+VIN)

Notes on the sheet:
V_in Range: 4.5-18 V
1206 0 ohm used in place of L1 because L1 is not in stock at Digi-Key as of 10/22/2020

Parts:
D3: LG R971-KN-1; 0805; MPN LG R971-KN-1; Digi-Key_PN 475-1410-1-ND
J5: EBC20DRAS
J6: Conn_01x03; PinHeader_1x03_P2.54mm_Vertical; MPN 61300311121
J13: Conn_01x02; PinHeader_1x02_P2.54mm_Vertical; MPN 61300211121
JP1, JP2: JUMPER-SMT_3_1-NC; SMT-JUMPER_3_1-NC_TRACE_NO-SILK
R12: 909; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder; MPN RC0805FR-07909RL

Connections:
+9V: J5.39, J5.40, J6.2, J13.1
+BATT: J5.31, J6.1
/Card Edge Conn/9V_PS: J6.3; also elsewhere on the board
/Card Edge Conn/GPS.RXD: JP2.2; also elsewhere on the board
/Card Edge Conn/GPS.TXD: JP1.2; also elsewhere on the board
/Card Edge Conn/HEADER1.1: J5.14; also elsewhere on the board
/Card Edge Conn/HEADER1.2: J5.22; also elsewhere on the board
/Card Edge Conn/HEADER1.3: J5.24; also elsewhere on the board
/Card Edge Conn/HEADER1.4: J5.28; also elsewhere on the board
/Card Edge Conn/HEADER1.5: J5.25; also elsewhere on the board
/Card Edge Conn/HEADER1.6: J5.27; also elsewhere on the board
/Card Edge Conn/HEADER1.7: J5.29; also elsewhere on the board
/Card Edge Conn/HEADER1.9: J5.35; also elsewhere on the board
/Card Edge Conn/HEADER1.10: J5.37; also elsewhere on the board
/Card Edge Conn/J5.2: J5.11; also elsewhere on the board
/Card Edge Conn/J5.3: J5.32; also elsewhere on the board
/Card Edge Conn/ST7-ICCCLK: J5.3; also elsewhere on the board
/Card Edge Conn/ST7-ICCDATA: J5.6; also elsewhere on the board
/Card Edge Conn/ST7-ICCSEL: J5.4; also elsewhere on the board
/Card Edge Conn/ST7-RESET: J5.5; also elsewhere on the board
/Card Edge Conn/SW1.1: J5.18; also elsewhere on the board
/Card Edge Conn/SW1.2: J5.17; also elsewhere on the board
/Card Edge Conn/SW1.3: J5.36; also elsewhere on the board
/Card Edge Conn/SW1.4: J5.13; also elsewhere on the board
/Card Edge Conn/U3.18: J5.38; also elsewhere on the board
/Card Edge Conn/U3.19: J5.21; also elsewhere on the board
/Card Edge Conn/U21.20-DCLK: J5.12; also elsewhere on the board
/Card Edge Conn/U22.3: J5.30; also elsewhere on the board
GND: J5.9, J5.10, J5.15, J5.16, J5.19, J5.20, J5.33, J5.34, R12.2; also elsewhere on the board
unnamed: D3.1, J13.2
unnamed: D3.2, R12.1
unnamed: J5.23, JP1.3, JP2.1
unnamed: J5.26, JP1.1, JP2.3
VDD: J5.1, J5.2, J5.7, J5.8; also elsewhere on the board

Notes on the sheet:
Jumper Sullins Connector Solutions NPC02SXON-RC Jumper 1-2 to power from LMS6 Battery Jumper 2-3 to power from exteral power
Remove jumper to allow for more accurate power measurements

Schematic: eFuse.sch

Parts:
C10: DNP; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
D1: LH_R974-LP-1; 0805; MPN LH R974-LP-1; Digi-Key_PN 475-1415-1-ND
R6: 470K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder; MPN RC0805FR-07470KL
R7: 137K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder; MPN ERJ-6ENF1373V
R8: 54.9K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder; MPN RC0805FR-0754K9L
R9: 1.62K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder; MPN ERJ-6ENF1621V
R10: 143K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder; MPN ERJ-6ENF1433V
U3: TPS25921ADR; SOIC-8_W5.4mm; MPN TPS25921ADR

Connections:
/DC-DC Converter/+V_in: U3.5; also elsewhere on the board
/eFuse/eFuse_In: D1.1, R6.1, U3.4; also elsewhere on the board
GND: C10.2, R8.2, R10.2, U3.1; also elsewhere on the board
unnamed: C10.1, U3.2
unnamed: D1.2, R9.2
unnamed: R6.2, R7.1, U3.3
unnamed: R7.2, R8.1, U3.8
unnamed: R9.1, U3.6
unnamed: R10.1, U3.7

Notes on the sheet:
Power Failure Detection Threshold: ... 4.62V Release UVLO, Enable Chip: ............... 4.79V Over Voltage Cut-off: ....................... 16.76V Release OV: ..................................... 16.16 V Current LImit: .................................. 1.51 A Current LImit Fast Trip: ............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

Board: 2 copper layers, 80.0 x 96.0 mm, 47 parts (8 on the bottom side), 61 nets.

File Fabrication/REV A/Interface Board BOM Rev A.xlsx:

REF | Value | Manufacturer Part Number | Manufacturer | Quantity
C4 | 33nF | 885012207095 | Würth Elektronik | 1
> C3, C5, C6 | 0.1uF | CL21B104KBCNNNC | Samsung Electro-Mechanics | 3
C7 | 10uF | T491A106K010AT |  | 1
C8 | 10uF | CL31A106KAHNNNE | Samsung Electro-Mechanics | 1
C9 | 4.7uF | C3216X7R1E475K160AC | TDK Corporation | 1
C10 | DNP | ~ | ~ | 1
D1 | LH_R974-LP-1 | LH R974-LP-1 | OSRAM Opto Semiconductors Inc. | 1
> D2, D3 | LG R971-KN-1 | LG R971-KN-1 | OSRAM Opto Semiconductors Inc. | 2
> FB1, FB2 | MPZ2012S601AT000 | MPZ2012S601AT000 | TDK Corporation | 2
> J1, J12 | 105-1103-001 | 105-1103-001 | Cinch Connectivity Solutions Johnson | 2
> J2, J6, J10 | Conn_01x03 | 61300311121 | Würth Elektronik | 3
> J3, J11 | 105-1102-001 | 105-1102-001 | Cinch Connectivity Solutions Johnson | 2
J4 | UJ2-MIBH-4-SMT-TR | UJ2-MIBH-4-SMT-TR | CUI Inc. | 1
J5 | 5-5530843-4 | 5-5530843-4 | TE Connectivity AMP Connectors | 1
J7 | 302-S101 | 302-S101 | On Shore Technology Inc. | 1
J9 | Conn_02x18_Odd_Even | PREC020DAAN-RC | Sullins Connector Solutions | 1
J13 | Conn_01x02 | 61300211121 | Würth Elektronik | 1
> JP1, JP2, JP4, JP5 | JUMPER-SMT_3_1-NC |  |  | 4
L1 | TCK-154 | TCK-154 | Traco Power | 1
> R1, R2 | 27 | CRG0805F27R | TE Connectivity Passive Product | 2
R3 | 1.5K | CRGCQ0805F1K5 | TE Connectivity Passive Product | 1
R4 | 10k | RC1005F103CS | Samsung Electro-Mechanics | 1
R5 | 470 | RC0805JR-07470RL | Yageo | 1
R6 | 470K | RC0805FR-07470KL | Yageo | 1
R7 | 137K | ERJ-6ENF1373V | Panasonic Electronic Components | 1
R8 | 54.9K | RC0805FR-0754K9L | Yageo | 1
R9 | 1.62K | ERJ-6ENF1621V | Panasonic Electronic Components | 1
R10 | 143K | ERJ-6ENF1433V | Panasonic Electronic Components | 1
R11 | 280 | RC0805FR-07280RL | Yageo | 1
R12 | 909 | RC0805FR-07909RL | Yageo | 1
R13 | 1M | RC0805FR-071ML | Yageo | 1
U1 | FT2232D-REEL | FT2232D-REEL | FTDI, Future Technology Devices International Ltd | 1
U2 | TEC2-1219WI |  |  | 1
U3 | TPS25921x |  |  | 1
Y1 | CSTNR6M00GH5C000R0 | CSTNR6M00GH5C000R0 | Murata Electronics | 1

## Commit log

2020-10-06 Commit of Programmer Board Files
    Initial commit of all the KiCad files
2020-10-16 Added DC-DC converter
2020-10-16 Create LICENSE
2020-10-16 Added libraries used in the project. Top level connections.
    Added libraries used in this project to the project folder.
    Made additonal top level connections on the top level schematic.
2020-10-16 Delete Card Edge Conn.sch
    This was an early attempt that is not needed.
2020-10-16 Updated EdgeCardConn.sch with GPS UART
    Confiremed the GPS UART pins from discord chat.
2020-10-16 Annotated schematics and added UART Jumpers
    Annotated schematics.
    Added jumpers to GPS UART because I'm still not 100% sure on the connections and I don't want to have to respin a board because I was wrong.
2020-10-17 completed connections
2020-10-17 eFuse added
    Added eFuse, LEDs, and addtional power configuration options.
2020-10-17 Change Sheets to US Letter
2020-10-17 Fixed J9 hanging over edge of sheet
2020-10-17 Fixed J6 footprint and MPN info
2020-10-17 Updated rev number on all sheets
2020-10-17 Changed J9 connections to help with layout.
2020-10-17 Initial pcb commit.
2020-10-18 Changed crystal for resonator. Board Layout.
2020-10-18 Fixed DRC Errors
    Fixed drc errors
2020-10-18 Fabrication outputs
    Added fabrication outputs
2020-10-18 Added SecKC Logo
2020-10-18 Adjustment to logo placement
2020-10-18 Fixing component field names, because I can't spell.
2020-10-22 Final updates to REV B
2020-10-22 Reorganzied the included symbol and footprint libraries
2020-10-30 Added product info and Schematic
2020-11-10 Changed dk library
    Changed dk library to github linked lib.
2020-11-10 Fixed USB pins
    Fixed USB pin swap. Closes #7
2020-11-28 Rev C Board layout
2020-11-29 Rev C PCB as sent to fabrication
    REV C PCB as sent to fabrication with clean up directory structure.
2020-11-29 Updated fabrication output
2020-11-29 Main directory cleanup
    main directory cleanup. Moved KiCad project files into KiCad folder
2020-11-29 More KiCad cleanup
2020-12-13 Updated part numbers to match
    Updated part numbers on components to fix errors.
2020-12-20 Created BOM for LMS6 Interface board Rev C
    Created BOM for LMS6 Interface board Rev C
2020-12-20 Updated README.md with build and fabrication notes
2020-12-21 Added picture to README.md
2020-12-21 Change image link on README.md
    Raw image seems a little big. Setting raw=false
2020-12-21 Cropped and resized LMS6_Interface.jpg
    Original was way too yuuuge.

Notices in the files:
KiCad Files/Programmer Board.kicad_pcb:
GPL 3.0
